# IAR project blfw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VE ST STM32F207VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL; USE_USB_OTG_FS; USE_EMBEDDED_PHY
  ICCARM.CCIncludePath2: ; ..\Libraries\CMSIS\CM3\CoreSupport; ..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\Libraries\STM32F2xx_StdPeriph_Driver\inc; usb_vcp; ..\Libraries\STM32_USB_OTG_Driver\inc; ..\Libraries\STM32_USB_Device_Library\Core\inc; ..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\Utilities\FatFs; ..\Utilities\STM32_EVAL; ..\Utilities\STM32_EVAL\Common; ..\Utilities\STM32_EVAL\STM322xG_EVAL
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: blfw.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c stm32f2xx_conf.h stm32f2xx_it.c stm32f2xx_it.h
  group adc
    ./: adc12.c adc12.h
  group dac
    ./: dac.c dac.h
  group eval
    ../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval.h stm322xg_eval_sdio_sd.c stm322xg_eval_sdio_sd.h
  group FatFs
    ../Utilities/FatFs/: diskio.h ff.c ff.h ffconf.h integer.h sdio-stm32f2.c typedefs.h
  group periph_driver
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group startup
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group systick
    ./: systick.c systick.h
  group timer
    ./: timer.c timer.h
  group USB Device/Class/CDC
    ../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB Device/Library
    ../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Drivers
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group usb_vcp
    usb_vcp/: usb_bsp.c usb_conf.h usbd_cdc_vcp.c usbd_cdc_vcp.h usbd_conf.h usbd_desc.c usbd_desc.h usbd_usr.c
  group utils
    ./: utils.c utils.h
